FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-Fixed-exception-when-loading-existing-log-entries.patch"
