# Enable threshold sensor event monitoring for SEL/Redfish logging
PACKAGECONFIG:append = " log-threshold"
