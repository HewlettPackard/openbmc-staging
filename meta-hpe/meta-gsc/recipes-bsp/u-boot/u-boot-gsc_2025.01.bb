require recipes-bsp/u-boot/u-boot.inc
require u-boot-gsc.inc

SRCREV = "50fee8f668f2b0b18ba1b166d44a11136c785905"

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"
