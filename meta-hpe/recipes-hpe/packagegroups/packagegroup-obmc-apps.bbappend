
RDEPENDS:${PN}-leds:remove = " \
        phosphor-led-manager-faultmonitor \
        "
