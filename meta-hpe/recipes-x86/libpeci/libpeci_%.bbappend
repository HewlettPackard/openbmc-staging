FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-disabling-print-statement-about-assigned-PECI-dev-na.patch"

